## base_external/package/climate_control/Config.in
```kconfig
config BR2_PACKAGE_CLIMATE_CONTROL
	bool "climate-control"
	help
	  Climate Control System: kernel drivers.
```
